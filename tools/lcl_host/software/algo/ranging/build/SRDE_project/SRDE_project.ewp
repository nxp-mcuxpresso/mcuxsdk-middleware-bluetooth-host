# IAR project SRDE_project.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: KW45B41Z83 NXP KW45B41Z83
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_KW45B41Z83AFTA; COMPONENT_COMMON; COMPONENT_MUSIC; COMPONENT_H2COV; COMPONENT_EVD; COMPONENT_TESTSUPPORT; COMPONENT_CRNPC; COMPONENT_EIGEN_SOLVER_SAES; COMPONENT_EIGEN; EIGEN_MPL2_ONLY; UNITY_EXCLUDE_SETJMP_H=1; RANGE_CHECK=1; USE_MEMTRACE=0; USE_STOPWATCH=0; STOPWATCH_MAXNESTING=1; MEMORY_RECORD_CSTACK=0; DISPLAY_HEAP_FOR_EACH_TEST; GLOBAL_DEF_EVD_TYPE; TEST_CASE_MEASUREMENT; TEST_CASE_EVDPOWER_VS_EVDSAES=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\..\..\boards\kw45b41zevk\demo_apps\hello_world; ..\..\..\..\..\..\..\..\..\..\boards\kw45b41zevk; ..\..\..\..\..\..\..\..\..\..\boards\kw45b41zevk\utility; ..\..\..\..\..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\..\..\..\CMSIS\DSP\Include; ..\..\..\..\..\..\..\..\..\..\CMSIS\DSP\Source\MatrixFunctions; ..\..\..\..\..\..\..\..\..\..\platform\utilities\debug_console_lite; ..\..\..\..\..\..\..\..\..\..\platform\utilities\str; ..\..\..\..\..\..\..\..\..\..\platform\drivers\common; ..\..\..\..\..\..\..\..\..\..\platform\drivers\ccm32k; ..\..\..\..\..\..\..\..\..\..\platform\drivers\lpuart; ..\..\..\..\..\..\..\..\..\..\platform\drivers\gpio; ..\..\..\..\..\..\..\..\..\..\platform\drivers\lpuart; ..\..\..\..\..\..\..\..\..\..\platform\drivers\port; ..\..\..\..\..\..\..\..\..\..\components\lists; ..\..\..\..\..\..\..\..\..\..\components\uart; ..\..\..\..\..\..\..\..\..\..\devices\KW45B41Z83; ..\..\..\..\..\..\..\..\..\..\devices\KW45B41Z83\drivers; ..\..\libs\common; ..\..\libs; ..\..\libs\common\include\memory; ..\..\libs\eigenSolverSaes\include; ..\..\libs\music\include; ..\..\libs\h2cov\include; ..\..\libs\evd\include; ..\..\libs\crNonPhaseCoherent\include; ..\..\libs\channelReconstruct_2D\include; ..\..\libs\testsupport\include; ..\..\tests\music\src; ..\..\tests\crNonPhaseCoherent\src; ..\..\tests\eigenevd\src; ..\..\thirdparty\Eigen\eigen-3.3.7; ..\..\thirdparty\Unity\Unity\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: SRDE_project.bin
  ILINK.IlinkOutputFile: SRDE_project.out
  ILINK.IlinkIcfFile: KW45B41Z83/iar/kw45b41z_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../../../CMSIS/DSP/Lib/IAR/iar_ARMv8MMLldfsp_math.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_KW45B41Z83AFTA; CR2D; COMPONENT_COMMON; COMPONENT_MUSIC; COMPONENT_H2COV; COMPONENT_EVD; COMPONENT_TESTSUPPORT; COMPONENT_CRNPC; COMPONENT_EIGEN_SOLVER_SAES; COMPONENT_EIGEN; EIGEN_MPL2_ONLY; UNITY_EXCLUDE_SETJMP_H=1; RANGE_CHECK=0; USE_MEMTRACE=0; USE_STOPWATCH=0; STOPWATCH_MAXNESTING=1; MEMORY_RECORD_CSTACK=0; TEST_CASE_EVDPOWER_VS_EVDSAES=0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: NDEBUG
  ILINK.IlinkOutputFile: hello_world.out
  group board
    ../../../../../../../../../../boards/kw45b41zevk/: board.c board.h clock_config.c clock_config.h
    ../../../../../../../../../../boards/kw45b41zevk/demo_apps/hello_world/: pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../../../../../../CMSIS/DSP/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
    ../../../../../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    ../../../../../../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    ../../../../../../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../../../../../../devices/KW45B41Z83/: fsl_device_registers.h KW45B41Z83.h KW45B41Z83_features.h system_KW45B41Z83.c system_KW45B41Z83.h
  group drivers
    ../../../../../../../../../../platform/drivers/ccm32k/: fsl_ccm32k.c fsl_ccm32k.h
    ../../../../../../../../../../devices/KW45B41Z83/drivers/: fsl_clock.c fsl_clock.h
    ../../../../../../../../../../platform/drivers/common/: fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h
    ../../../../../../../../../../platform/drivers/gpio/: fsl_gpio.c fsl_gpio.h
    ../../../../../../../../../../platform/drivers/lpuart/: fsl_lpuart.c fsl_lpuart.h
    ../../../../../../../../../../platform/drivers/port/: fsl_port.h
  group KW45B41Z83/iar
    KW45B41Z83/iar/: kw45b41z_flash.icf
  group ranging
    ../../libs/common/src/memory/: allocator.cpp memory.cpp
    ../../libs/channelReconstruct_2D/src/: ChannelReconstruct_2D.cpp
    ../../libs/eigenSolverSaes/src/: EigenSolverSaes.cpp
    ../../libs/evd/src/: evd.cpp
    ../../libs/common/src/: Functions.cpp measurement_tools.c memtrace.c RangingSettings.cpp Stopwatch.cpp
    ../../libs/h2cov/src/: h2cov.cpp
    ../../tests/music/src/: H_est_data.cpp IQ_data_py.cpp main.cpp test_execute.cpp test_music_ranging.cpp test_music_ranging_IQ_ant_path.cpp test_music_ranging_p054.cpp test_music_ranging_p054_matlab.cpp test_music_real.cpp
    ../../libs/music/src/: MusicRanging.cpp
    ../../libs/crNonPhaseCoherent/src/: reconstructNonPhaseCoherent.cpp
    ../../tests/eigenevd/src/: test_impl.cpp
    ../../tests/crNonPhaseCoherent/src/: test_reconstructNonPhaseCoherent.cpp
    ../../libs/testsupport/src/: test_utils.cpp
    ../../thirdparty/Unity/Unity/src/: unity.c
  group startup
    ../../../../../../../../../../devices/KW45B41Z83/iar/: startup_KW45B41Z83.s
  group utilities
    ../../../../../../../../../../platform/utilities/assert/: fsl_assert.c
    ../../../../../../../../../../platform/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
    ../../../../../../../../../../platform/utilities/str/: fsl_str.c fsl_str.h
